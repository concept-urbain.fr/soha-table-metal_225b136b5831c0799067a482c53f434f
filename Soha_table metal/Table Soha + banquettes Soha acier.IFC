Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Table Soha + banquettes Soha acier.IFC
Time: 2020-05-06T06:47:59
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: H M8 A2_Default (8)
In: Default Storey
Material: 0

# IfcBeam: ROND-M8-A2_Default (31)
In: Default Storey
Material: 0

# IfcBeam: SOHA-BANQ-DTE-003_Default (3)
In: Default Storey
Material: 0

# IfcBeam: SOHA-BANQ-DTE-NEW-004_Default (5)
In: Default Storey
Material: 0

# IfcBeam: SOHA-BANQ-MUL-001_Default (3)
In: Default Storey
Material: 0

# IfcBeam: SOHA-BANQ-MUL-002_Default (2)
In: Default Storey
Material: 0

# IfcBeam: SOHA-BANQ-MUL-003_Default (3)
In: Default Storey
Material: 0

# IfcBeam: SOHA-BANQ-MUL-TUB-AC-006_Default (9)
In: Default Storey
Material: 0

# IfcBeam: SOHA-BANQ-MUL-TUB-AC-007_Default (8)
In: Default Storey
Material: 0

# IfcBeam: SOHA-TAB-DEM-006_Default
In: Default Storey
Material: 0

# IfcBeam: SOHA-TAB-DEM-008_Default
In: Default Storey
Material: 0

# IfcBeam: TBHC-M8x20-A2_Default (15)
In: Default Storey
Material: 0

# IfcBeam: TH M8x25 ZN_Default (9)
In: Default Storey
Material: 0

# IfcBuildingElementProxy: H M8 A2_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: ROND-M8-A2_Default (6)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SOHA-BANQ-DTE-003_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SOHA-BANQ-DTE-NEW-004_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SOHA-BANQ-MUL-001_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SOHA-BANQ-MUL-002_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SOHA-BANQ-MUL-003_Default (5)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SOHA-BANQ-MUL-TUB-AC-006_Default (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SOHA-BANQ-MUL-TUB-AC-007_Default (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SOHA-TAB-DEM-003_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SOHA-TAB-DEM-004_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SOHA-TAB-DEM-005_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SOHA-TAB-DEM-006_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SOHA-TAB-DEM-007_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SOHA-TAB-DEM-008_Default (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SOHA-TAB-DEM-009_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Symétrie-SOHA-TAB-DEM-004_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: TBHC-M8x20-A2_Default (12)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: TH M8x25 ZN_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0
